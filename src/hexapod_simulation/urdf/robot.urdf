Commit message: save

File: src/hexapod_simulation/urdf/robot.urdf (robot description, URDF)
Before this commit: robot hexapod_simulation, 19 links, 18 joints
Links:
- link base_link: mass 2.22661 -> 2.54608
